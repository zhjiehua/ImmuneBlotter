# Keil uVision project project.uvprojx, settings and files
target Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\User;..\..\emWin\Config;..\..\emWin\DisplayDriver;..\..\emWin\emWinTask;..\..\emWin\Include;..\..\User\fonts;..\..\User\FatFS\src;..\..\Libraries\CMSIS\Include;..\..\User\MyProject\WDAGUI;..\..\User\MyProject\WDAProMan;..\..\User\MyProject\WildfireGUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f10x_it.c stm32f10x_assert.c
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_uart_fifo.c bsp_user_lib.c bsp_spi_bus.c bsp_eeprom_24xx.c bsp_i2c_gpio.c bsp_tim_pwm.c bsp_fsmc_sram.c bsp_sdio_sd.c bsp_timer.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_crc.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group LCD_Driver
    ../../User/bsp/src/: bsp_gt811.c bsp_ra8875_flash.c bsp_ra8875_port.c bsp_tft_lcd.c bsp_touch.c bsp_tsc2046.c LCD_ILI9488.c LCD_RA8875.c LCD_SPFD5420.c param.c
    ../../emWin/DisplayDriver/: GUIDRV_Template.c
  group Fonts
    ../../User/fonts/: asc12.c asc16.c hz12.c hz16.c hz24.c hz32.c fonts.h ra8875_asc_width.c
  group GUI_X
    ../../emWin/GUI_X/: GUI_X.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group GUI/DEMO
    ../../emWin/emWinTask/: MainTask.c MainTask.h
  group GUI/Lib
    ../../emWin/GUILib/: STemWin528_CM3_Keil.lib
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.开发环境说明.txt
  group Pictures
    ../../User/MyProject/Pictures/: Icon_Backflow.c Icon_Calibration.c Icon_Information.c Icon_Project.c Icon_ProjectEdit.c Icon_Purge.c
  group WDAGUI
    ../../User/MyProject/WDAGUI/: JMGUI_DMX512_Setting.c JMGUI_DMX512_Test.c WDAGUI_Action.c WDAGUI_Backflow.c WDAGUI_Calibration.c WDAGUI_Information.c WDAGUI_Project.c WDAGUI_ProjectEdit.c WDAGUI_Purge.c
  group WDAProMan
    ../../User/MyProject/WDAProMan/: WDAProEdit.c
  group WildfireGUI
    ../../User/MyProject/WildfireGUI/: WFGUI_APPLinkedList.c WFGUI_DeskTop.c WFGUI_Icon.c WFGUI_UserAPP.c WFGUI_Phone.c
